options:
  parameters:
    generate_options: qt_gui
    id: Lab2_GNU_Loopback
    output_language: python
    title: ECE531 Lab2 Loopback
  states: {}

blocks:
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Manual Gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.084e6
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    label: Source to Frequency
    start: '1'
    step: 1e3
    stop: '100000'
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
