options:
  parameters:
    generate_options: qt_gui
    id: loopback_iio
    output_language: python
    title: IIO Loopback
  states: {}

blocks:
- name: URI
  id: variable
  parameters:
    value: '''ip:192.168.2.1'''
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Manual Gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2083999'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    label: Source to Frequency
    start: '1'
    step: 1e3
    stop: '100000'
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''voltage0'''
    device: '''ad9361-phy'''
    output: 'False'
    uri: URI
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''voltage0'''
    device: '''ad9361-phy'''
    output: 'False'
    uri: URI
  states: {}
- name: iio_attr_sink_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''altvoltage0'''
    device: '''ad9361-phy'''
    output: 'True'
    uri: URI
  states: {state: disabled}
- name: iio_attr_sink_0_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''altvoltage1'''
    device: '''ad9361-phy'''
    output: 'True'
    uri: URI
  states: {state: disabled}
- name: iio_attr_sink_0_0_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''altvoltage1'''
    device: '''ad9361-phy'''
    output: 'True'
    uri: URI
  states: {}
- name: iio_attr_sink_0_0_0_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''altvoltage0'''
    device: '''ad9361-phy'''
    output: 'True'
    uri: URI
  states: {}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''voltage0'''
    device: '''ad9361-phy'''
    output: 'False'
    uri: URI
  states: {state: disabled}
- name: iio_attr_sink_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''voltage0'''
    device: '''ad9361-phy'''
    output: 'False'
    uri: URI
  states: {}
- name: iio_attr_sink_0_1_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '''voltage0'''
    device: '''ad9361-phy'''
    output: 'False'
    uri: URI
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: '''hardwaregain'''
    interval: '1000'
    value: '''20.000000 dB'''
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: '''gain_control_mode'''
    interval: '1000'
    value: '''manual'''
  states: {}
- name: iio_attr_updater_0_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '''frequency'''
    interval: '1000'
    value: '2400000000'
  states: {state: disabled}
- name: iio_attr_updater_0_0_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '''frequency'''
    interval: '1000'
    value: '2400000000'
  states: {state: disabled}
- name: iio_attr_updater_0_0_0_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '''frequency'''
    interval: '1000'
    value: '915000000'
  states: {}
- name: iio_attr_updater_0_0_0_0_1
  id: iio_attr_updater
  parameters:
    attr: '''frequency'''
    interval: '1000'
    value: '915000000'
  states: {}
- name: iio_attr_updater_0_1
  id: iio_attr_updater
  parameters:
    attr: '''sampling_frequency'''
    interval: '1000'
    value: '2083999'
  states: {state: disabled}
- name: iio_attr_updater_0_1_0
  id: iio_attr_updater
  parameters:
    attr: '''quadrature_tracking_en'''
    interval: '1000'
    value: '1'
  states: {}
- name: iio_attr_updater_0_1_1
  id: iio_attr_updater
  parameters:
    attr: '''sampling_frequency'''
    interval: '1000'
    value: '3000000'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[''voltage0'', ''voltage1'']'
    decimation: '1'
    device: '''cf-ad9361-lpc'''
    device_phy: '''ad9361-phy'''
    params: '[]'
    uri: URI
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: URI
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_fmcomms2_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '1']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0_0, out, iio_attr_sink_0_0_0_0, attr]
- [iio_attr_updater_0_0_0_0_0, out, iio_attr_sink_0_0_0_0_0, attr]
- [iio_attr_updater_0_0_0_0_0_0, out, iio_attr_sink_0_0_0_0_0_0, attr]
- [iio_attr_updater_0_0_0_0_1, out, iio_attr_sink_0_0_0_0_1, attr]
- [iio_attr_updater_0_1, out, iio_attr_sink_0_1, attr]
- [iio_attr_updater_0_1_0, out, iio_attr_sink_0_1_0, attr]
- [iio_attr_updater_0_1_1, out, iio_attr_sink_0_1_1, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_1, '0']

metadata:
  file_format: 1
